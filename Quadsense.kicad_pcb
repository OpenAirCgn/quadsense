# Repository OpenAirCgn/quadsense

File README.md:

# OpenAir Quadsense Module

This is an extension module for the OpenAir.cgn base board
to connect to Alphasense gas concentration sensors using
Alphasense ISB boards to provide amplifier circuitry.

## KiCad design Quadsense.kicad_pcb

Parts:
C1, C2, C4, C6, C9, C11: 1u; 0603
C3, C5, C7, C12, C13, C14, C15, C17, C18: 0.1u; 0603
C8, C10: 10u; 0603
C16: DNP; 0603
EXT1, EXT2, EXT3, EXT4: ExternalComp; ALPHASENSE-ISB
H1, H2, H3, H4: HOLE; HOLE-3.2
IC1, IC4: BME280
IC2: AP7330; SOT23-5
IC3: ADC_LTC2497; QFN-38-12-7-0.5-EP
L1: 22u 50mA; 0805
LOGO1: Logo
P1, P2, P3, P4: CONN_6; HEADER-1x06-1.27-ZZ-POL
P5: CONN_8; HEADER-1x08-1.27-ZZ-POL
Q1: AO3418; SOT23-3
R1, R10: 10K; 0603
R2: 9K1; 0603
R3: 2K2; 0603
R4, R5: DNP; 0603
R6, R7, R8, R9, R11: 0/DNP; 0603

Connections:
4V: C4.1, C6.1, C7.1, C8.1, IC2.5 (VOUT), IC3.28 (VCC), L1.1, R2.1, R6.1, R8.1, R10.1
EN: IC2.3 (EN), P5.8, R1.1
ID1: P5.4, Q1.1 (G)
unnamed: IC2.4 (adj/nc), R2.2, R3.1
unnamed: IC3.24 (MUXOUTP), IC3.25 (ADCINP)
unnamed: IC3.26 (ADCINN), IC3.27 (MUXOUTN)
unnamed: IC3.36 (CA0), Q1.3 (D), R10.2, R11.1
unnamed: IC3.37 (CA1), R6.2, R7.1
unnamed: IC3.38 (CA2), R8.2, R9.1
SCL: IC1.4 (SCK/SCL), IC3.2 (SCL), IC4.4 (SCK/SCL), P5.5, R4.2
SDA: IC1.3 (SDI/SDA), IC3.3 (SDA), IC4.3 (SDI/SDA), P5.7, R5.2
SENS0CH0+: IC3.8 (CH0), P1.3
SENS0CH0-: IC3.9 (CH1), P1.4
SENS0CH1+: IC3.10 (CH2), P1.5
SENS0CH1-: IC3.11 (CH3), P1.6
SENS1CH0+: IC3.12 (CH4), P2.3
SENS1CH0-: IC3.13 (CH5), P2.4
SENS1CH1+: IC3.14 (CH6), P2.5
SENS1CH1-: IC3.15 (CH7), P2.6
SENS2CH0+: IC3.16 (CH8), P3.3
SENS2CH0-: IC3.17 (CH9), P3.4
SENS2CH1+: IC3.18 (CH10), P3.5
SENS2CH1-: IC3.19 (CH11), P3.6
SENS3CH0+: IC3.20 (CH12), P4.3
SENS3CH0-: IC3.21 (CH13), P4.4
SENS3CH1+: IC3.22 (CH14), P4.5
SENS3CH1-: IC3.23 (CH15), P4.6

Notes on the sheet:
Note: 4V and A4V are actually 4.11V. Both low noise.
3V3 5V GND ID1 SCL ID2 SDA EN
Uplink
Sensor conn
Analog power
Temp / humidity
ADC
Note: Direct wire to board connector footprint is reversed from the ordinary plug connector. In layout, footprint is on top side to allow direct connector from bottom side.

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
Board: 2 copper layers, 90.0 x 100.0 mm, 49 parts (34 on the bottom side), 31 nets.

## Commit log

2019-03-18 Initial version
2019-03-20 Copper pour inset, added Gerber files
2019-06-04 Added second BME280, fixed footprints, better analog decoupling, resized module board
2019-06-04 Saved files
2019-06-06 Silkscreen fixes
2019-06-06 Saved changes
2019-08-29 BOM changes, BOM rename
2019-08-29 alphasense docs
2021-02-03 README, pics
